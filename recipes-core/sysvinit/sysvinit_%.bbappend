FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

# override rc script in openembedded-core layer.